TYPE "UR__O2T_ints"
VERSION : 0.1


  STRUCT
   Register : ARRAY  [0 .. 11 ] OF DINT ;
  END_STRUCT ;
END_TYPE

